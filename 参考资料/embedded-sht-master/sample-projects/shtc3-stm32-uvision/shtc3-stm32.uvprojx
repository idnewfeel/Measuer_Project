# Keil uVision project shtc3-stm32.uvprojx, settings and files
target STM32-Discovery (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SHTC3_SampleCode +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD_VL
  c include: .\shtc1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./Source/: startup_stm32f10x_md_vl.s
  group Source Files
    ./Source/: main.c system.c sensirion_sw_i2c_implementation.c
  group shtc1
    ./shtc1/: sensirion_common.c sht_git_version.c
    ./shtc1/sw_i2c/: sensirion_sw_i2c.c
    ../../shtc1/: shtc1_example_usage.c shtc1.c
software components: CMSIS:CORE 5.1.1
